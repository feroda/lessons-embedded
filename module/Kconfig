## module/Kconfig
```kconfig
config EXAMPLES
    tristate "Enable Examples"
    default M
    help
      Enable compilation option for driver examples
```
